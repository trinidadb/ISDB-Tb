<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>full_transceiver_isdbt</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>IIP2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,2,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-0.00003</value></param>
<param><key>step</key><value>0.000001</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>IP3</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,3,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-0.00003</value></param>
<param><key>step</key><value>0.000001</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>active_carriers</value></param>
<param><key>value</key><value>13*108*2**(mode-1)+1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha</value></param>
<param><key>comment</key><value>Averaging is implemented with a first order IIR filter with parameter  d_alpha.</value></param>
<param><key>value</key><value>0.05</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>canal_ideal</value></param>
<param><key>value</key><value>1.0+1.0j</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>canal_moderado</value></param>
<param><key>value</key><value>[1.0+1.0j,0.3+0.2j,0.2+0.01j,0.0001]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>canal_picante</value></param>
<param><key>value</key><value>[1.0+1.0j,0.9+0.8j,0.8+0.67j,0.5+0.4j,0.3+0.2j,0.2+0.01j,0.0001+0.009j,0.00001j]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>const_size</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_carriers</value></param>
<param><key>value</key><value>13*96*2**(mode-1)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_error</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>2,2,1,2</value></param>
<param><key>label</key><value>Frequency Error</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>50</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>guard</value></param>
<param><key>value</key><value>1.0/16</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>i_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>length_a</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>length_b</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>length_c</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>mag_imbalance</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mode</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise</value></param>
<param><key>value</key><value>1e-9</value></param>
<param><key>gui_hint</key><value>2,0,1,2</value></param>
<param><key>label</key><value>Channel noise</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1e-9</value></param>
<param><key>step</key><value>1e-6</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>number_segments_a</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>number_segments_b</value></param>
<param><key>value</key><value>12</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>number_segments_c</value></param>
<param><key>value</key><value>13-number_segments_b-number_segments_a</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ph_imbalance</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ph_noise</value></param>
<param><key>value</key><value>-40</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-40</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>q_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,3,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>8e6*64/63</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>segments_a</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>segments_b</value></param>
<param><key>value</key><value>12</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>segments_c</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>start_segment_a</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>start_segment_b</value></param>
<param><key>value</key><value>start_segment_a+number_segments_a</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>start_segment_c</value></param>
<param><key>value</key><value>start_segment_b+number_segments_b</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>total_carriers</value></param>
<param><key>value</key><value>2**(10+mode)</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>result_layer_b.ts</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/littlequeen/Downloads/Final/result_layer_a.ts</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/littlequeen/Downloads/Final/layer_a.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>/home/littlequeen/Downloads/Final/layer_b.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>comment</key><value>Debo hacer esto ya que mi constelacion no esta
normalizada, luego divido su maximo valor por
el maximo valor que pueden tomar mis simbolos:
(1.1500126123428345/1.08148944133956)</value></param>
<param><key>const</key><value>1.1500126123428345/1.081</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>0</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>384</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_peak_detector2_fb</key>
<param><key>id</key><value>blocks_peak_detector2_fb_0</value></param>
<param><key>alpha</key><value>0.001</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>look_ahead</key><value>2000</value></param>
<param><key>threshold_factor_rise</key><value>0.3</value></param>
</block>
<block>
<key>blocks_sample_and_hold_xx</key>
<param><key>id</key><value>blocks_sample_and_hold_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>comment</key><value>See sec. 3.9.2 of the standard.

Delay  adjustment  Transmission and reception delays equivalent to 120 
carrier symbols occur as a result of bit interleaving of thecarrier modulator.
The delay time varies depending on the carrier modulation scheme, that is,
the number of bits comprising the carrier symbol.  This difference in delay 
time is corrected at the bit interleaving input side through the addition of the 
delay-adjustment value shown in Table 3-9 such that the total transmission 
and reception delays are equal to 2 OFDM symbols.</value></param>
<param><key>num_items</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>data_carriers</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>188</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>188</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>188</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>188</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>1512*4</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>1512*4</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>96*(2**(mode-1))*number_segments_a</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_3_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>108*(2**(mode-1))*13+1</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_3_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>96*(2**(mode-1))*number_segments_b</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1</value></param>
<param><key>freq_offset</key><value>freq_error</value></param>
<param><key>noise_voltage</key><value>noise</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>canal_ideal</value></param>
</block>
<block>
<key>channels_impairments</key>
<param><key>id</key><value>channels_impairments_0</value></param>
<param><key>freq_offset</key><value>0</value></param>
<param><key>magbal</key><value>mag_imbalance</value></param>
<param><key>phasebal</key><value>ph_imbalance</value></param>
<param><key>i_ofs</key><value>0</value></param>
<param><key>phase_noise_mag</key><value>ph_noise</value></param>
<param><key>q_ofs</key><value>0</value></param>
<param><key>gamma</key><value>0</value></param>
<param><key>beta</key><value>IP3</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0</value></param>
<param><key>cp_len</key><value>int(total_carriers*guard)</value></param>
<param><key>input_size</key><value>total_carriers</value></param>
<param><key>tagname</key><value></value></param>
</block>
<block>
<key>dtv_dvbt_inner_coder</key>
<param><key>id</key><value>dtv_dvbt_inner_coder_0_0</value></param>
<param><key>code_rate</key><value>C2_3</value></param>
<param><key>constellation</key><value>qpsk</value></param>
<param><key>hierarchy</key><value>alpha4</value></param>
<param><key>ninput</key><value>1</value></param>
<param><key>noutput</key><value>1512*4</value></param>
</block>
<block>
<key>dtv_dvbt_inner_coder</key>
<param><key>id</key><value>dtv_dvbt_inner_coder_0_0_0</value></param>
<param><key>code_rate</key><value>C3_4</value></param>
<param><key>constellation</key><value>64qam</value></param>
<param><key>hierarchy</key><value>alpha4</value></param>
<param><key>ninput</key><value>1</value></param>
<param><key>noutput</key><value>1512*4</value></param>
</block>
<block>
<key>dtv_dvbt_reed_solomon_enc</key>
<param><key>id</key><value>dtv_dvbt_reed_solomon_enc_0</value></param>
<param><key>blocks</key><value>1</value></param>
<param><key>gfpoly</key><value>0x11d</value></param>
<param><key>k</key><value>239</value></param>
<param><key>n</key><value>255</value></param>
<param><key>s</key><value>51</value></param>
<param><key>m</key><value>8</value></param>
<param><key>p</key><value>2</value></param>
<param><key>t</key><value>8</value></param>
</block>
<block>
<key>dtv_dvbt_reed_solomon_enc</key>
<param><key>id</key><value>dtv_dvbt_reed_solomon_enc_0_0</value></param>
<param><key>blocks</key><value>1</value></param>
<param><key>gfpoly</key><value>0x11d</value></param>
<param><key>k</key><value>239</value></param>
<param><key>n</key><value>255</value></param>
<param><key>s</key><value>51</value></param>
<param><key>m</key><value>8</value></param>
<param><key>p</key><value>2</value></param>
<param><key>t</key><value>8</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_1</value></param>
<param><key>fft_size</key><value>total_carriers</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(total_carriers)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>isdbt_bit_deinterleaver</key>
<param><key>id</key><value>isdbt_bit_deinterleaver_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>segments</key><value>segments_b</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_bit_deinterleaver</key>
<param><key>id</key><value>isdbt_bit_deinterleaver_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>constellation_size</key><value>4</value></param>
<param><key>segments</key><value>segments_a</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_byte_deinterleaver</key>
<param><key>id</key><value>isdbt_byte_deinterleaver_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>isdbt_byte_deinterleaver</key>
<param><key>id</key><value>isdbt_byte_deinterleaver_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>isdbt_byte_interleaver</key>
<param><key>id</key><value>isdbt_byte_interleaver_0</value></param>
<param><key>constellation_size</key><value>4</value></param>
<param><key>nsegments</key><value>segments_a</value></param>
<param><key>rate</key><value>1</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_byte_interleaver</key>
<param><key>id</key><value>isdbt_byte_interleaver_0_0</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>nsegments</key><value>segments_b</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_carrier_modulation</key>
<param><key>id</key><value>isdbt_carrier_modulation_0</value></param>
<param><key>constellation_size</key><value>4</value></param>
<param><key>segments</key><value>segments_a</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_carrier_modulation</key>
<param><key>id</key><value>isdbt_carrier_modulation_0_0</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>segments</key><value>segments_b</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_energy_descrambler</key>
<param><key>id</key><value>isdbt_energy_descrambler_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>isdbt_energy_descrambler</key>
<param><key>id</key><value>isdbt_energy_descrambler_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>isdbt_energy_dispersal</key>
<param><key>id</key><value>isdbt_energy_dispersal_0</value></param>
<param><key>constellation_size</key><value>4</value></param>
<param><key>nsegments</key><value>segments_a</value></param>
<param><key>rate</key><value>1</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_energy_dispersal</key>
<param><key>id</key><value>isdbt_energy_dispersal_0_0</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>nsegments</key><value>segments_b</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_frequency_deinterleaver</key>
<param><key>id</key><value>isdbt_frequency_deinterleaver_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>oneseg</key><value>True</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_frequency_interleaver</key>
<param><key>id</key><value>isdbt_frequency_interleaver_0</value></param>
<param><key>oneseg</key><value>True</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_hierarchical_combinator</key>
<param><key>id</key><value>isdbt_hierarchical_combinator_0</value></param>
<param><key>segments_A</key><value>segments_a</value></param>
<param><key>segments_B</key><value>segments_b</value></param>
<param><key>segments_C</key><value>0</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_ofdm_synchronization</key>
<param><key>id</key><value>isdbt_ofdm_synchronization_0</value></param>
<param><key>cp_length</key><value>0.0625</value></param>
<param><key>interpolate</key><value>True</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_pilot_signals</key>
<param><key>id</key><value>isdbt_pilot_signals_0</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_reed_solomon_dec_isdbt</key>
<param><key>id</key><value>isdbt_reed_solomon_dec_isdbt_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>isdbt_reed_solomon_dec_isdbt</key>
<param><key>id</key><value>isdbt_reed_solomon_dec_isdbt_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>isdbt_subset_of_carriers</key>
<param><key>id</key><value>isdbt_subset_of_carriers_0</value></param>
<param><key>first</key><value>(96*2**(mode-1))*start_segment_a</value></param>
<param><key>last</key><value>(96*2**(mode-1))*(start_segment_a+number_segments_a)-1</value></param>
<param><key>total</key><value>13*96*2**(mode-1)</value></param>
</block>
<block>
<key>isdbt_subset_of_carriers</key>
<param><key>id</key><value>isdbt_subset_of_carriers_0_0</value></param>
<param><key>first</key><value>(96*2**(mode-1))*start_segment_b</value></param>
<param><key>last</key><value>(96*2**(mode-1))*(start_segment_b+number_segments_b)-1</value></param>
<param><key>total</key><value>13*96*2**(mode-1)</value></param>
</block>
<block>
<key>isdbt_symbol_demapper</key>
<param><key>id</key><value>isdbt_symbol_demapper_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>constellation_size_A</key><value>4</value></param>
<param><key>segments_A</key><value>segments_a</value></param>
<param><key>constellation_size_B</key><value>64</value></param>
<param><key>segments_B</key><value>segments_b</value></param>
<param><key>constellation_size_C</key><value>64</value></param>
<param><key>segments_C</key><value>segments_c</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_time_deinterleaver</key>
<param><key>id</key><value>isdbt_time_deinterleaver_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>length_A</key><value>length_a</value></param>
<param><key>segments_A</key><value>segments_a</value></param>
<param><key>length_B</key><value>length_b</value></param>
<param><key>segments_B</key><value>segments_b</value></param>
<param><key>length_C</key><value>length_c</value></param>
<param><key>segments_C</key><value>segments_c</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_time_interleaver</key>
<param><key>id</key><value>isdbt_time_interleaver_0</value></param>
<param><key>length_A</key><value>length_a</value></param>
<param><key>segments_A</key><value>segments_a</value></param>
<param><key>length_B</key><value>length_b</value></param>
<param><key>segments_B</key><value>segments_b</value></param>
<param><key>length_C</key><value>length_c</value></param>
<param><key>segments_C</key><value>segments_c</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_tmcc_decoder</key>
<param><key>id</key><value>isdbt_tmcc_decoder_0</value></param>
<param><key>print_params</key><value>False</value></param>
<param><key>transmission_mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_tmcc_encoder</key>
<param><key>id</key><value>isdbt_tmcc_encoder_0</value></param>
<param><key>int_length_A</key><value>length_a</value></param>
<param><key>mod_scheme_A</key><value>4</value></param>
<param><key>conv_code_A</key><value>1</value></param>
<param><key>nsegs_A</key><value>segments_a</value></param>
<param><key>int_length_B</key><value>length_b</value></param>
<param><key>mod_scheme_B</key><value>64</value></param>
<param><key>conv_code_B</key><value>2</value></param>
<param><key>nsegs_B</key><value>segments_b</value></param>
<param><key>int_length_C</key><value>0</value></param>
<param><key>mod_scheme_C</key><value>4</value></param>
<param><key>conv_code_C</key><value>0</value></param>
<param><key>nsegs_C</key><value>0</value></param>
<param><key>one_seg_present</key><value>True</value></param>
<param><key>mode</key><value>3</value></param>
</block>
<block>
<key>isdbt_viterbi_decoder</key>
<param><key>id</key><value>isdbt_viterbi_decoder_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>constellation_size</key><value>64</value></param>
<param><key>rate</key><value>2</value></param>
</block>
<block>
<key>isdbt_viterbi_decoder</key>
<param><key>id</key><value>isdbt_viterbi_decoder_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>constellation_size</key><value>4</value></param>
<param><key>rate</key><value>1</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>5.8e6/2.0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>0.5e6</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>mer_probe_mer_c</key>
<param><key>id</key><value>mer_probe_mer_c_0_0</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>comment</key><value>Ej_Objeto_Constelacion:
Constellation Points = [(-3-3j), (-1-3j), (1-3j), (3-3j), (-3-1j), (-1-1j), (1-1j), (3-1j), (-3+1j), (-1+1j), (1+1j), (3+1j), (-3+3j), (-1+3j), (1+3j), (3+3j)]
Symbol Map = [0, 4, 12, 8, 1, 5, 13, 9, 3, 7, 15, 11, 2, 6, 14, 10]</value></param>
<param><key>symbol_table</key><value>digital.constellation_qpsk().points()</value></param>
</block>
<block>
<key>mer_probe_mer_c</key>
<param><key>id</key><value>mer_probe_mer_c_0_0_0</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>symbol_table</key><value>digital.qam_constellation(64).points()</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>tab_id@1</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0_0</value></param>
<param><key>gui_hint</key><value>tab_id@2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0_0_0</value></param>
<param><key>gui_hint</key><value>tab_id@3</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab_id@0</value></param>
<param><key>label1</key><value>ISDB-Tb</value></param>
<param><key>label2</key><value>ISDB-Tb+Filtro</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>gui_hint</key><value>tab_id@2</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>MER (dB)</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0</value></param>
<param><key>gui_hint</key><value>tab_id@3</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>MER (dB)</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"reed-solomon"</value></param>
<param><key>size</key><value>total_carriers</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-9</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_1</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"viterbi"</value></param>
<param><key>size</key><value>total_carriers*24</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-9</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab_id</value></param>
<param><key>label0</key><value>Espectro_TX+Perturbaciones</value></param>
<param><key>label1</key><value>All</value></param>
<param><key>label2</key><value>Layer_A</value></param>
<param><key>label3</key><value>Layer_B</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_peak_detector2_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_sample_and_hold_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>mer_probe_mer_c_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0</source_block_id><sink_block_id>blocks_sample_and_hold_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_sample_and_hold_xx_0</source_block_id><sink_block_id>qtgui_number_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>isdbt_pilot_signals_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>dtv_dvbt_reed_solomon_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>dtv_dvbt_reed_solomon_enc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>channels_impairments_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_0</source_block_id><sink_block_id>blocks_null_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1</source_block_id><sink_block_id>isdbt_carrier_modulation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1_0</source_block_id><sink_block_id>isdbt_carrier_modulation_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_3</source_block_id><sink_block_id>mer_probe_mer_c_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_3</source_block_id><sink_block_id>qtgui_const_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_3_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_3_1</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_3_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_3_1</source_block_id><sink_block_id>qtgui_const_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_impairments_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_inner_coder_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_inner_coder_0_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_reed_solomon_enc_0</source_block_id><sink_block_id>isdbt_energy_dispersal_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_reed_solomon_enc_0_0</source_block_id><sink_block_id>isdbt_energy_dispersal_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_bit_deinterleaver_0</source_block_id><sink_block_id>isdbt_viterbi_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_bit_deinterleaver_0_0</source_block_id><sink_block_id>isdbt_viterbi_decoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_deinterleaver_0</source_block_id><sink_block_id>isdbt_energy_descrambler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_deinterleaver_0_0</source_block_id><sink_block_id>isdbt_energy_descrambler_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_interleaver_0</source_block_id><sink_block_id>dtv_dvbt_inner_coder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_byte_interleaver_0_0</source_block_id><sink_block_id>dtv_dvbt_inner_coder_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_carrier_modulation_0</source_block_id><sink_block_id>isdbt_hierarchical_combinator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_carrier_modulation_0_0</source_block_id><sink_block_id>isdbt_hierarchical_combinator_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>isdbt_energy_descrambler_0</source_block_id><sink_block_id>isdbt_reed_solomon_dec_isdbt_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_descrambler_0_0</source_block_id><sink_block_id>isdbt_reed_solomon_dec_isdbt_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_dispersal_0</source_block_id><sink_block_id>isdbt_byte_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_energy_dispersal_0_0</source_block_id><sink_block_id>isdbt_byte_interleaver_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_frequency_deinterleaver_0</source_block_id><sink_block_id>isdbt_time_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_frequency_interleaver_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_hierarchical_combinator_0</source_block_id><sink_block_id>isdbt_time_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_ofdm_synchronization_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_ofdm_synchronization_0</source_block_id><sink_block_id>isdbt_tmcc_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_pilot_signals_0</source_block_id><sink_block_id>isdbt_tmcc_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_reed_solomon_dec_isdbt_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_reed_solomon_dec_isdbt_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_reed_solomon_dec_isdbt_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_subset_of_carriers_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_subset_of_carriers_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_3_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_symbol_demapper_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_symbol_demapper_0</source_block_id><sink_block_id>isdbt_bit_deinterleaver_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_symbol_demapper_0</source_block_id><sink_block_id>isdbt_bit_deinterleaver_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_time_deinterleaver_0</source_block_id><sink_block_id>isdbt_symbol_demapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_time_interleaver_0</source_block_id><sink_block_id>isdbt_frequency_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_tmcc_decoder_0</source_block_id><sink_block_id>isdbt_frequency_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_tmcc_decoder_0</source_block_id><sink_block_id>isdbt_subset_of_carriers_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_tmcc_decoder_0</source_block_id><sink_block_id>isdbt_subset_of_carriers_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_tmcc_encoder_0</source_block_id><sink_block_id>fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_viterbi_decoder_0</source_block_id><sink_block_id>isdbt_byte_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_viterbi_decoder_0</source_block_id><sink_block_id>blocks_nlog10_ff_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>isdbt_viterbi_decoder_0_0</source_block_id><sink_block_id>isdbt_byte_deinterleaver_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>isdbt_ofdm_synchronization_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>mer_probe_mer_c_0_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mer_probe_mer_c_0_0_0</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
